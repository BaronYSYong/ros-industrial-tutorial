Commit message: workcell.urdf: resize the height(z)

File: myworkcell_support/urdf/workcell.urdf (robot description, URDF)
Before this commit: robot myworkcell, 3 links, 2 joints
Links:
- link table: geometry collision box size=0.6 0.6 2.0; visual box size=0.6 0.6 2.0
